# Keil uVision project HU-017B-RDA5807B.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000)
  output: HU-017B-RDA5807B +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: delay.c delay.h main.c
    ./config/: Config.c Config.h EEPROM.c EEPROM.h
    ./rda5807/: I2C.c I2C.h RDA5807M.c RDA5807M.h
    ./led/: myLed.c myLed.h
    ./uart/: uart.c uart.h
    ./key/: Key.c Key.h
    ./time/: timer.c
